## ncs-fund/v2.x.x/lesson3/fund_less3_exer1/Kconfig
```kconfig
# This file has to do with files and building


source "Kconfig.zephyr"

config MYFUNCTION
	bool "Enable my function"
	default n
```
